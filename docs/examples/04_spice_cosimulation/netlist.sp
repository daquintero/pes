* `ngspice` Sim Input for `__main__.TransientTb`
* Generated by `vlsirtools.NgspiceNetlister`
*
* Anonymous `circuit.Package`
* Generated by `vlsirtools.NgspiceNetlister`
*

.SUBCKT Straight
+ e1 e2
* No parameters

rr1
+ e1 e2
+ 1000
* No parameters

.ENDS

.SUBCKT TransientTb
+ VSS
* No parameters

vVPULSE
+ VPULSE_p VSS
+ pulse ('-1000m' '1000m' '1m' '10m' '10m' '75m' '100m')
* No parameters

xdut
+ VPULSE_p VSS
+ Straight
* No parameters

.ENDS

xtop 0 TransientTb // Top-Level DUT

.tran 0.0001 0.2
